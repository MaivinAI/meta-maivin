# Removing rsvg which fails to build.
PACKAGECONFIG = ""