BUILD_CFLAGS += "-Wno-error=deprecated-declarations"