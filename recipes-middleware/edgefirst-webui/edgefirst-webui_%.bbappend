SRC_URI = "git://github.com/EdgeFirstAI/webui.git;protocol=https;branch=feature/MVN2-160-lidar"
SRCREV = "beb0a4eb0e3415aed34930e7576ae23a2a6d075d"
