FILESEXTRAPATHS_append := "${THISDIR}/u-boot-toradex:"
SRC_URI_append = " file://0001-Use-maivin-as-the-default-fdt_board.patch"
