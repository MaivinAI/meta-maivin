SRC_URI = "https://adis.deepviewml.com/yocto/vaal/vaal-licensed-${PV}-linux-armv8.zip;subdir=${S}"
SRC_URI[sha256sum] = "1926a9bc482a7a5229d4f0b7715ad7b5a0e4e9374639bd43d1ca0d0d81691eeb"