#SRCREV = "637bb424dc317a044c722a671355ef9df0e0d30f"
SRC_URI = "git://github.com/pmem/ndctl.git;branch=main;protocol=https"
