PACKAGECONFIG:append = " iptc"