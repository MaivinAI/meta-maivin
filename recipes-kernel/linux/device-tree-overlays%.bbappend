FILESEXTRAPATHS:prepend := "${THISDIR}/device-tree-overlays:"

SRC_URI:append = " file://Device_tree.patch"